# Keil uVision project STM32F407VG.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407VG +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\system;.\lib\inc;.\startup;.\cmsis;.\app;.\drive;.\user;.\app\mpu6050;.\STemWin\Config;.\STemWin\inc;.\STemWin\OS;.\uC-CPU;.\uC-LIB;.\uCOS-CORE;.\uCOS-PORT;.\uCOS_BSP;.\uCOS_CONFIG
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./user/: main.c stm32f4xx_it.c task.c
  group APP
    ./app/: ANO_DT.c gps.c led.c printf.c beep.c nrf24l01.c key.c motor.c hmc5883.c mpu9250.c show.c RC.c ili9488.c input_ctrl.c
  group Drive
    ./drive/: clock.c dma.c systick.c usart.c iic.c pwm.c timer.c spi.c exti.c fsmc.c lcd_fonts.c sys.c adc.c
  group System
    ./system/: system_stm32f4xx.c
  group Startup
    ./startup/: startup_stm32f40_41xxx.s
  group Library
    ./lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group dsp
    ./lib/: arm_cortexM4lf_math.lib
  group mpu6050
    ./app/mpu6050/: mpu6050.c ahrs.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
